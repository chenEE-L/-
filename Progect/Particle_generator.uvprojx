# Keil uVision project Particle_generator.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Particle_generator +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4,USE_USB_OTG_FS,STM32F4XX,
  c misc: --C99
  c include: ..\UcosII\Source;..\User;..\App;..\Bsp;..\CMSIS\Driver;..\CMSIS\Core;..\CMSIS\STM32F4x7_ETH_Driver\inc;..\CMSIS\STM32F4x7_ETH_Driver\src;..\UcosII\Port;..\lwip_v1.3.2\port\STM32F4x7\Standalone;..\lwip_v1.3.2\src\api;..\lwip_v1.3.2\src\core\ipv4;..\lwip_v1.3.2\src\include\ipv4\lwip;..\lwip_v1.3.2\src\include\lwip;..\lwip_v1.3.2\src\netif\ppp;..\lwip_v1.3.2\port\STM32F4x7\arch;..\lwip_v1.3.2\src\include\netif;..\lwip_v1.3.2\src\include;..\lwip_v1.3.2\src\include\lwip;..\lwip_v1.3.2\port\STM32F4x7;..\lwip_v1.3.2\src\include\ipv4;E:\Keil_v5\ARM\CMSIS\Include;D:\Keil_v5\ARM\CMSIS\Include;..\FATFS;..\FATFS\option;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\usbh_mass_storage;..\USB\STM32_USB_HOST_Library\Class\HID\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: app.c serial_cmd.c CRC.c main.c filter.c Temperature.c moter.c fatfs.c GetCommend.c dgus.c beionfluid_s60.c ry_wsy301.c
  group Bsp
    ../Bsp/: stm32f4xx_it.c NVIC.C Bsp_Global.c usart.c LED.C bsp.c RS485.c SPI.c time.c AD7606.c IO.c gps.c ftl.c nand.c dac7512n.c
  group CMSIS/Driver
    ../CMSIS/Driver/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_fsmc.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS/Core
    ../CMSIS/Core/: startup_stm32f4xx.s system_stm32f4xx.c
  group UcosII/Source
    ../UcosII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UcosII/Ports
    ../UcosII/Port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group Documentation
    ../Documentation/: DebugLog.txt GX6621命令说明.txt text1.txt
  group Fatfs
    ../FATFS/: diskio.c SPI_SD_driver.c ff.c
    ../FATFS/option/: cc936.c
  group STM32_USB_HOST
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_core.c usbh_msc_bot.c
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_ioreq.c usbh_hcs.c usbh_core.c
  group STM32_USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_hcd.c usb_core.c
  group USBH_Mass_Storage
    ../USB/usbh_mass_storage/: usb_bsp.c usbh_usr.c
software components: CMSIS:CORE 4.3.0
